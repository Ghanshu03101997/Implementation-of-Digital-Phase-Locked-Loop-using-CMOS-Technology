* C:\Users\HP\eSim-Workspace\PLL\PLL.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 09/29/22 23:03:43

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
M11  Net-_M11-Pad1_ Net-_M11-Pad2_ Net-_M11-Pad3_ GND eSim_MOS_N
M12  Net-_M11-Pad3_ Net-_C1-Pad1_ GND GND eSim_MOS_N
M14  Net-_M13-Pad3_ Net-_M11-Pad2_ Net-_M11-Pad1_ GND eSim_MOS_P
M18  Net-_M17-Pad3_ Net-_M11-Pad1_ Net-_M15-Pad1_ GND eSim_MOS_P
M15  Net-_M15-Pad1_ Net-_M11-Pad1_ Net-_M15-Pad3_ GND eSim_MOS_N
M16  Net-_M15-Pad3_ Net-_C1-Pad1_ GND GND eSim_MOS_N
M22  Net-_M21-Pad3_ Net-_M15-Pad1_ Vout Net-_M19-Pad3_ eSim_MOS_P
M9  Net-_M10-Pad3_ Net-_M3-Pad1_ Net-_M11-Pad2_ GND eSim_MOS_P
M6  Net-_M5-Pad3_ Vout Net-_M3-Pad1_ GND eSim_MOS_P
M20  Vout Net-_M15-Pad1_ Net-_M19-Pad1_ Net-_M19-Pad3_ eSim_MOS_N
M19  Net-_M19-Pad1_ Net-_C1-Pad1_ Net-_M19-Pad3_ ? eSim_MOS_N
M7  Net-_M11-Pad2_ Net-_M3-Pad1_ Net-_M7-Pad3_ GND eSim_MOS_N
M8  Net-_M7-Pad3_ Net-_C1-Pad1_ GND GND eSim_MOS_N
M3  Net-_M3-Pad1_ Vout Net-_M3-Pad3_ GND eSim_MOS_N
M4  Net-_M3-Pad3_ Net-_C1-Pad1_ ? ? eSim_MOS_N
M5  Net-_M10-Pad1_ Net-_M1-Pad1_ Net-_M5-Pad3_ Net-_M10-Pad1_ eSim_MOS_P
M10  Net-_M10-Pad1_ Net-_M1-Pad1_ Net-_M10-Pad3_ Net-_M10-Pad1_ eSim_MOS_P
M13  Net-_M10-Pad1_ Net-_M1-Pad1_ Net-_M13-Pad3_ Net-_M10-Pad1_ eSim_MOS_P
M17  Net-_M10-Pad1_ Net-_M1-Pad1_ Net-_M17-Pad3_ Net-_M10-Pad1_ eSim_MOS_P
M21  Net-_M10-Pad1_ Net-_M1-Pad1_ Net-_M21-Pad3_ Net-_M10-Pad1_ eSim_MOS_P
M2  Net-_M10-Pad1_ Net-_M1-Pad1_ Net-_M1-Pad1_ Net-_M10-Pad1_ eSim_MOS_P
M1  Net-_M1-Pad1_ Net-_C1-Pad1_ GND GND eSim_MOS_N
v2  Net-_M10-Pad1_ GND DC
M26  Vout Vin ? Net-_M24-Pad4_ eSim_MOS_P
M25  Net-_M25-Pad1_ Vin GND GND eSim_MOS_N
M24  Vin Vout Net-_M23-Pad1_ Net-_M24-Pad4_ eSim_MOS_P
M23  Net-_M23-Pad1_ Vout GND GND eSim_MOS_N
M28  Net-_M24-Pad4_ Net-_M25-Pad1_ ? Net-_M24-Pad4_ eSim_MOS_P
M30  Net-_M24-Pad4_ Net-_M27-Pad1_ Net-_M29-Pad1_ Net-_M24-Pad4_ eSim_MOS_P
M27  Net-_M27-Pad1_ Net-_M25-Pad1_ ? ? eSim_MOS_N
M29  Net-_M29-Pad1_ Net-_M23-Pad1_ GND GND eSim_MOS_N
M32  Net-_M24-Pad4_ Net-_M29-Pad1_ Net-_M31-Pad1_ Net-_M24-Pad4_ eSim_MOS_P
M31  Net-_M31-Pad1_ Net-_M29-Pad1_ Net-_M31-Pad3_ Net-_M31-Pad3_ eSim_MOS_N
v3  Net-_M24-Pad4_ GND DC
v1  Vin GND pulse
C1  Net-_C1-Pad1_ GND 10p
R1  Net-_M31-Pad1_ Net-_C1-Pad1_ 300k

.end
